<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\A31T216.ewp</path>
    </project>
    <batchBuild />
</workspace>

# IAR project A31T216.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31T216 ABOV A31T216
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: A31T216; IAR_CC
  ICCARM.CCIncludePath2: ..\..\..\core\cmsis\include; ..\..\..\core\device\a31t21x\include; ..\..\..\driver\a31t21x\include; code_app\library\header; code_app; ..\..\..\library\ul60730\library\include; ..\..\..\library\ul60730\example
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A31T216.srec
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkAdditionalLibs: code_app\library\touch_V109_IAR83_240222.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    code_app/: a31t21x_port_init.c a31t21x_system_setting.c debug.c i2c.c led_driver.c main.c register_map.c touch_config.c user_function.c user_timer.c
  group core
    ../../../core/device/a31t21x/source/: a31t21x_startup_iar.s a31t21x_system.c
  group driver
    ../../../driver/a31t21x/source/: a31t21x_dma.c a31t21x_gpio.c a31t21x_led.c a31t21x_pwr.c a31t21x_scu.c a31t21x_timer.c a31t21x_uart.c a31t21x_usart1n.c a31t21x_wdt.c

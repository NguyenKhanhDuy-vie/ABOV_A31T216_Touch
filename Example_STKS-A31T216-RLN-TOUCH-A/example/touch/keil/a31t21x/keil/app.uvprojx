# Keil uVision project app.uvprojx, settings and files
target A31T21X (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: A31T216 KEIL_CC
  c include: ..\..\..\..\..\core\device\a31t21x\include;..\..\..\..\..\driver\a31t21x\include;..\..\code_app\library\header;..\..\common;..\..\..\..\..\core\cmsis\include;..\..\code_app,..\..\..\..\..\library\ul60730\library\include,..\..\..\..\..\library\ul60730\example
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../../code_app/: main.c a31t21x_system_setting.c a31t21x_port_init.c debug.c led_driver.c user_timer.c i2c.c user_function.c register_map.c touch_config.c
  group core
    ../../../../../core/device/a31t21x/source/: a31t21x_system.c a31t21x_startup_arm.s
  group driver
    ../../../../../driver/a31t21x/source/: a31t21x_dma.c a31t21x_gpio.c a31t21x_led.c a31t21x_pwr.c a31t21x_scu.c a31t21x_timer.c a31t21x_uart.c a31t21x_usart1n.c a31t21x_wdt.c a31t21x_adc.c a31t21x_crc.c a31t21x_fmc.c a31t21x_fmc_self.c a31t21x_i2c.c a31t21x_lcd.c a31t21x_spi.c a31t21x_timer30.c a31t21x_wt.c
  group doc
    ../../../../../doc/: LICENSE.md
  group touch_lib
    ../../code_app/library/Objects/: touch_V109_240222.lib
